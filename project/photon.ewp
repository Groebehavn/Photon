# IAR project photon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\source\includes; ..\source\libraries\CMSIS\ST\STM32F4xx\Include; ..\source\libraries\CMSIS\Include; ..\source\libraries\STM32F4xx_StdPeriph_Driver\inc; ..\source\utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: photon.hex
  ILINK.IlinkOutputFile: photon.out
  ILINK.IlinkIcfFile: ..\source\linker\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../source/: main.c
  group discovery
    ../source/utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group iar
    ../source/iar/: startup_stm32f4xx.s stm32f4xx_it.c system_stm32f4xx.c
  group linker
    ../source/linker/: stm32f407xG.icf
  group periph
    ../source/libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group source
    ../source/: program.c
  group source/server
    ../source/: gpio.c quantum.c quantumfifo.c quantumserver.c timer.c triled.c trileddriver.c
  group source/storage
    ../source/: storage.c
  group source/system
    ../source/: statemachine.c
